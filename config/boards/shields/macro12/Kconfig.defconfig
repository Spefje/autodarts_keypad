## config/boards/shields/macro12/Kconfig.defconfig
```kconfig
if SHIELD_MACRO12

config ZMK_KEYBOARD_NAME
    default "Autodarts Keypad"

endif
```
